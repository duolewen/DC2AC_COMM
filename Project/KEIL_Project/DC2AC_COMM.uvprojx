# Keil uVision project DC2AC_COMM.uvprojx, settings and files
target DC2AC_COM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303CE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.5.0
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DC2AC_COMM +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F30X_HD,__TARGET_FPU_VFP,ARM_MATH_CM4
  c include: ..\..\Project;..\..\Library\Firmware\CMSIS;..\..\Library\Firmware\GD32F30x_standard_peripheral\Include;..\..\APP\Include;..\..\Library\Firmware\CMSIS\GD\GD32F30x\Include;..\..\Library\Third_Party\FreeRTOSv10.1.1\FreeRTOS\Source\include;..\..\Library\Third_Party\FreeRTOSv10.1.1\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\Library\Utilities;..\..\Library\DSP;..\..\Task\Include;..\..\Untility\Include;..\..\Module\Include;..\..\Config;..\..\Protocol\Include;..\..\Library\RTT;..\..\Function\Include;..\..\UID_Encryption;..\..\APP\Module;..\..\APP\BMS\Hal;..\..\APP\BMS\Core;..\..\APP\BSP\inc;..\..\Driver\Include;..\..\APP\Module\Inc;..\..\Device\Include;..\..\APP\Protocol;..\..\APP\Untility\Include;..\..\APP\AFE\Inc;..\..\Library\lvgl-release-v8.3\lvgl-release-v8.3;..\..\Library\lvgl-release-v8.3\lvgl-release-v8.3\src;..\..\Library\lvgl-release-v8.3\lvgl-release-v8.3\examples\porting;..\..\Library\lvgl-release-v8.3\lvgl-release-v8.3\demos;..\..\Library\lvgl-release-v8.3\lvgl-release-v8.3\demos\stress
  library: MicroLIB
  memory RVCT4: ROM 0x8006000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../APP/Source/: main.c
  group Config
    ../../Config/: GlobalDef.h PinDef.h FreeRTOSConfig.h
  group Untility
    ../../APP/Untility/Source/: crc.c Untility.c Endian.c MyDelay.c
  group Device
    ../../Device/Source/: 24cxx.c KeyDet.c Sample.c Led.c
  group Driver
    ../../Driver/Source/: InitMCU.c FLASH.c gd32f30x_it.c FWDGT.c SimulationIicDriver.c UsartDriver.c SpiDriver.c AdcDriver.c TimerDriver.c
  group DSP
    ../../Library/DSP/: arm_cortexM4lf_math.lib
  group Startup
    ../../Library/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group CMSIS
    ../../Library/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group GD32F30x_Peripherals
    ../../Library/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group FreeRTOS
    ../../Library/Third_Party/FreeRTOSv10.1.1/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Library/Third_Party/FreeRTOSv10.1.1/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../Library/Third_Party/FreeRTOSv10.1.1/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Doc
    ../../Doc/: README.TXT
  group LVGL_Core
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group LVGL_Draw
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group LVGL_Extra
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/: lv_extra.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/layouts/flex/: lv_flex.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/layouts/grid/: lv_grid.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/libs/bmp/: lv_bmp.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/libs/freetype/: lv_freetype.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/libs/png/: lodepng.c lv_png.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/libs/rlottie/: lv_rlottie.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/others/gridnav/: lv_gridnav.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/others/ime/: lv_ime_pinyin.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/others/imgfont/: lv_imgfont.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/others/monkey/: lv_monkey.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/others/msg/: lv_msg.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/others/snapshot/: lv_snapshot.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/themes/basic/: lv_theme_basic.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/themes/default/: lv_theme_default.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/themes/mono/: lv_theme_mono.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/widgets/animimg/: lv_animimg.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/widgets/chart/: lv_chart.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/widgets/led/: lv_led.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/widgets/list/: lv_list.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/widgets/menu/: lv_menu.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/widgets/meter/: lv_meter.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/widgets/span/: lv_span.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/widgets/spinner/: lv_spinner.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/widgets/tabview/: lv_tabview.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/widgets/tileview/: lv_tileview.c
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/extra/widgets/win/: lv_win.c
  group LVGL_Font
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group LVGL_Hal
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LVGL_Misc
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group LVGL_Widget
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL_Porting
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/examples/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group LVGL_Demos
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/demos/stress/: lv_demo_stress.c
  group LVGL_Config
    ../../Library/lvgl-release-v8.3/lvgl-release-v8.3/: lv_conf.h lvgl.h
software components: CMSIS:CORE 5.1.2
